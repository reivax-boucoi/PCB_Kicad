File: hall_sensor_matrix/hall_sensor_matrix_v2/driver.kicad_sch (KiCad schematic)
At the start: 4 parts, among them Q1 VP3203

Commit message: a
Parts:
- renumbered R2 to R1, R1 to R2
